# Keil uVision project lcd.uvproj, settings and files
target lcd (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: lcd +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F030x6,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;                   ../Drivers/STM32F0xx_HAL_Driver/Inc;                   ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                   ../Drivers/CMSIS/Include;   ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
